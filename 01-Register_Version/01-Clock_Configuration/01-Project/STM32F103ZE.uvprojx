# Keil uVision project STM32F103ZE.uvprojx, settings and files
target STM32F103ZE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\02-Library\01-User;..\02-Library\03-CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../02-Library/01-User/: main.c
  group CMSIS
    ../02-Library/03-CMSIS/: startup_stm32f10x_hd.s
  group Readme
    ../: Readme.md
